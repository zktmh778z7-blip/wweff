# Keil uVision project 021_freemodbus_master.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: -DNDEBUG
  c include: .\SYSTEM;.\STARUP;.\FIRMWARE\inc;.\CORE;.\HARDWARE;..\USER;.\FreeModbus;.\FreeModbus\modbus\functions;.\FreeModbus\modbus\include;.\FreeModbus\modbus\rtu;.\FreeModbus\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group HARDWARE
    ./HARDWARE/: gpio.c usart.c timer.c ir.c usart4.c
  group FIRMWARE
    ./FIRMWARE/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./: stm32f10x_it.c main.c stm32f10x_it.h stm32f10x.h
  group SYSTEM
    ./SYSTEM/: delay.c system_stm32f10x.c sys.c
  group STARUP
    ./STARUP/: startup_stm32f10x_hd.s
  group CORE
    ./CORE/: core_cm3.c
  group FreeModBus
    ./FreeModbus/modbus/rtu/: mbrtu_m.c mbcrc.c
    ./FreeModbus/modbus/: mb_m.c
    ./FreeModbus/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c mbfuncother.c mbutils.c
    ./FreeModbus/port/: user_mb_app_m.c portevent_m.c portserial_m.c porttimer_m.c
